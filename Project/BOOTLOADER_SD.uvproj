# Keil uVision project BOOTLOADER_SD.uvproj, settings and files
target LM3S6911 (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: BOOTLOADER_SD_LM3S6911 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ../BootLoader/System/: Startup.s
  group DriverLib
    C:/Keil/ARM/RV31/LIB/Luminary/: DriverLib.lib
  group FS
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
    ../FS/SD/: File_Config.c Getline.c SD_File.c
    ../FS/: Serial.c Retarget.c fs_time.c SPI_LM3S37x8.c SPI_LM3S6965.c SPI_LM3S8962.c
  group XModem
    ../BootLoader/Xmodem/: xmodem.c
  group CFG
    ../CFG/: cfg.h
  group INC
    ../INC/: includes.h
