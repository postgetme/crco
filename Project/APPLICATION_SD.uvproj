# Keil uVision project APPLICATION_SD.uvproj, settings and files
target LM3S6911 (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: APPLICATION_SD_LM3S6911 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
