# Keil uVision project APPLICATION_FLASH.uvproj, settings and files
target LM3S6911 (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: APPLICATION_FLASH_LM3S6911 +hex
  AfterMake: fromelf --bin --output ..\Output\BIN\APPLICATION_FLASH_LM3S6911.bin ..\Output\OBJ\Application_Flash_LM3s6911\APPLICATION_FLASH_LM3S6911.axf
  c flags: Optim=1
  c include: ..\INC
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\System\LM3SXXXX_Flash.scat
  link misc: --entry ResetHndlr
  group System
    ../System/: LM3SXXXX_Flash.scat vectors.s init.s
  group DriverLib
    ../DriverLib/src/: adc.c can.c comp.c ethernet.c flash.c gpio.c hibernate.c i2c.c interrupt.c mpu.c pwm.c qei.c ssi.c sysctl.c systick.c timer.c uart.c udma.c usb.c watchdog.c cpu_keil.S
  group MyLib
    ../MyLib/Common/: common.c
    ../MyLib/SysInit/: sys_init.c
    ../MyLib/Uart/: my_uart.c
    ../MyLib/I2C/: i2c_driver.c pcf8563.c
    ../MyLib/GPIOControl/: gpio_control.c
    ../MyLib/SysPara/: sys_para.c
    ../MyLib/ResetKey/: reset_key.c
    ../MyLib/RGLed/: rg_led.c
  group OS
    ../UCOS/: os_hook.c os_cfg.h
    ../UCOS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../UCOS/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../UCOS/uC-LIB/: lib_mem.c lib_str.c
    ../UCOS/uC-CPU/: cpu_a.asm
  group Shell
    ../Shell/: shell.c shell.h
    ../Shell/sys_cmd/: sys_cmd.c
    ../Shell/fs_cmd/: fs_cmd.c
    ../Shell/tools/XModem/XModem_Recv/: xmodem_recv.c
    ../Shell/tools/com_tool/: com_tool.c
    ../Shell/tools/io_tool/: io_tool.c
  group FS
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
    ../FS/: fs_time.c Retarget.c SPI_LM3S37x8.c SPI_LM3S6965.c SPI_LM3S8962.c
    ../FS/Flash/: File_Config.c
    ../FS/Flash/W25X16/: FS_SPI_FlashPrg.c
  group XML
    ../XML/: mxml-attr.c mxml-entity.c mxml-file.c mxml-node.c mxml-private.c mxml-search.c mxml-set.c mxml-string.c
  group TCPIP
    ../TCPIP/: Net_Config.c LM3S_EMAC.c HTTP_uif.c HTTP_err.c FTP_uif.c
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
  group GUI
    ../GUI/LCD_Driver/: lcd.c
    ../GUI/Font/: font.c
    ../GUI/Graphic/: graphic.c
    ../GUI/KEY_Driver/: key.c key_phy.c key_hook.c
    ../GUI/Widget/: widget.c
    ../GUI/Widget/bar/: bar.c
    ../GUI/Widget/menu/: menu.c
    ../GUI/Widget/screen_protect/: screen_protect.c
    ../GUI/Widget/desktop/: desktop.c
    ../GUI/Widget/edit/: edit.c
    ../GUI/Widget/time_set/: time_set.c
    ../GUI/Widget/list/: list.c
  group CFG
    ../CFG/: cfg.h
  group INC
    ../INC/: includes.h
  group APP
    ../APP/: app.c app_task1.c app_task2.c app_task3.c app_task4.c app_task5.c
  group Main
    ../Main/: main.c
  group DOC
    ../DOC/: 常用代码.txt application代码说明.txt
