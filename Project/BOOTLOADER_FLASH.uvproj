# Keil uVision project BOOTLOADER_FLASH.uvproj, settings and files
target LM3S6911 (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: BOOTLOADER_FLASH_LM3S6911 +hex
  AfterMake: fromelf --bin --output ..\Output\BIN\BOOTLOADER_FLASH_LM3S6911.bin ..\Output\OBJ\Bootloader_Flash_LM3S6911\BOOTLOADER_FLASH_LM3S6911.axf
  c flags: Optim=1
  c include: ..\INC
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ../BootLoader/System/: Startup.s startup_rvmdk.S
  group DriverLib
    C:/Keil/ARM/RV31/LIB/Luminary/: DriverLib.lib
  group MyLib
    ../MyLib/GPIO_Control/: gpio_control.c
  group FS
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
    ../FS/Flash/: File_Config.c
    ../FS/: Serial.c Retarget.c fs_time.c SPI_LM3S37x8.c SPI_LM3S6965.c SPI_LM3S8962.c
    ../FS/Flash/W25X16/: FS_SPI_FlashPrg.c
  group XModem
    ../BootLoader/Xmodem/: xmodem.c
  group CFG
    ../CFG/: cfg.h
  group INC
    ../INC/: includes.h
  group APP
    ../BootLoader/APP/FLASH/: app.c
  group DOC
    ../DOC/: bootloader代码说明.txt
